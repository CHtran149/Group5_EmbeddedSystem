# Keil uVision project BTL_HTN.uvprojx, settings and files
target BTL_HTN (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BTL_HTN
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Lib\Base;.\Lib\lib_ST7735
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./Lib/main/: all_header.h main.c
  group lib
    ./Lib/Base/: uart.c uart.h pzem004t.c pzem004t.h spi.c spi.h st7735.c st7735.h buzzer.c buzzer.h
  group lib_st7735
    ./Lib/lib_ST7735/: Fontmaker.c Fontmaker.h graphic.c graphic.h IOT47_VN_font.c IOT47_VN_font.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.6.0, CMSIS:RTOS:FreeRTOS 10.3.1, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
