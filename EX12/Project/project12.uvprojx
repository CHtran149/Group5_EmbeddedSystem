# Keil uVision project project12.uvprojx, settings and files
target project12 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project12
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\FreeRTOS\inc;..\StdPeriph\inc;..\CMSIS\Core;..\CMSIS\Device\STM32F10X;..\Project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c
  group FreeRTOS
    ../FreeRTOS/src/: event_groups.c heap_4.c list.c port.c croutine.c queue.c stream_buffer.c tasks.c timers.c
  group StdPeriph
    ../StdPeriph/src/: stm32f10x_rcc.c stm32f10x_gpio.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
